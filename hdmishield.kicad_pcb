# Repository scaldov/HDMIshield

## KiCad design hdmishield.kicad_pcb

Parts:
C1, C6: 1uF; C_0805_2012Metric
C2, C7: 100uF; CP_EIA-7343-31_Kemet-D
C3, C5, C8, C10, C12, C14: 10uF; C_0805_2012Metric
C4, C9, C11, C13, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28, C29: 0.1uF; C_0603_1608Metric
J1, J2: HDMI_conn; HDMI-S-RA-T+SMT
L1, L2, L3, L4: L; L_1210_3225Metric_Pad1.42x2.65mm_HandSolder
P1, P2: CONN_02X32; PinHeader_2x32_P2.54mm_Vertical
P3: CONN_01X04; PinHeader_1x04_P2.54mm_Horizontal
P4: CONN_02X07; PinSocket_2x07_P2.54mm_Horizontal
R1, R2, R5, R6, R7, R8: 4K7; R_0603_1608Metric
R3: 887; R_1206_3216Metric
R4: 10K; R_0603_1608Metric
R9, R25, R28: 0*; R_0603_1608Metric
R10: 500; R_0603_1608Metric
R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R26, R27: 20K; R_0603_1608Metric
TP1, TP2: TestPoint; TestPoint_Pad_1.0x1.0mm
U1: AMS1117-3.3; SOT-223-3_TabPin2
U2: AZ1117-1.8; SOT-223-3_TabPin2
U3: ADV7513; TQFP-64-1EP_10x10mm_P0.5mm_EP5x5mm
U4: TFP410; TQFP-64-1EP_10x10mm_P0.5mm_EP5x5mm
W1, W2: TEST_1P; TestPoint_THTPad_D1.0mm_Drill0.5mm

Connections:
1V8: C10.1, C15.1, C16.1, C17.1, C18.1, L2.2, U3.1 (DVDD), U3.11 (DVDD), U3.31 (DVDD), U3.51 (DVDD)
3V3: C5.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, L1.2, R5.1, R6.1, R7.1, R10.2, R11.1, R12.1, R13.1, R14.1, R15.1, R16.1, R23.2, R24.2, R26.2, R27.2, U3.29 (DVDD_3V), U4.1, U4.3, U4.12, U4.18, U4.23, U4.29, U4.33
+3V3: P2.3, P2.4, P4.13, P4.14
+5V: C1.1, C2.1, C6.1, C7.1, J1.18 (+5V), J2.18 (+5V), P1.63, P1.64, P2.63, P2.64, R1.1, R2.1, U1.3 (VI), U2.3 (VI)
/B0A4: P2.26, U4.54
/B0A6: P2.22, U4.52
/B0A7: P2.20, U4.50
/B0A8: P2.18, U4.46
/B0A9: P2.16, U4.44
/B0A11: P2.14, U4.42
/B0A12: P2.12, U4.40
/B0A13: P2.10, U4.38
/B0A14: P2.7, U4.37
/B0B6: P2.23, U4.55
/B0B8: P2.19, U4.51
/B0B10: P2.15, U4.45
/B0B12: P2.11, U4.41
/B0B14: P2.8, U4.36
/B0C6: P2.38
/B0C7: P2.21, U4.53
/B0C9: P2.17, U4.47
/B0C10: P2.28, U4.58
/B0C11: P2.13, U4.43
/B0C13: P2.9, U4.39
/B0D6: P2.39
/B0D9: P2.32, U4.62
/B0E10: P2.27, U4.59
/B0E11: P2.29, U4.61
/B0F7: P2.37
/B0F9: P2.31, U4.63
/B0F10: P2.30, U4.60
/B1B15: P1.9
/B1B16: P1.10
/B1C15: P1.11
/B1C16: P1.12
/B1D14: P1.13
/B1D16: P1.14
/B1E7: P2.35
/B1E12: P1.7
/B1E13: P1.8
/B1E15: P1.15, P4.10
/B1E16: P1.16
/B1F12: P1.20, P4.7
/B1F13: P1.22, P4.5
/B1F14: P1.21, P4.4
/B1F15: P1.17, P4.8
/B1F16: P1.18, P4.9
/B1G11: P1.19, P4.6
/B1G12: P1.27, U3.8 (I2S3)
/B1G14: P1.24, P4.3
/B1G16: P1.23, P4.1
/B1H11: P1.28, U3.7 (I2S2)
/B1H13: P1.29, U3.6 (I2S1)
/B1H14: P1.30, U3.5 (I2S0)
/B1H15: P1.25, U3.10 (LRCLK)
/B1H16: P1.26, U3.9 (SCLK)
/B1J11: P1.33, U3.64 (HSYNC)
/B1J12: P1.34, U3.2 (VSYNC)
/B1J13: P1.36, U3.63 (DE)
/B1J14: P1.31, U3.4 (MCLK)
/B1J16: P1.32, U3.3 (SPDIF)
/B1K11: P1.41, U3.57 (DATA5)
/B1K12: P1.42, U3.58 (DATA4)
/B1K14: P1.35, U3.53 (CLK)
/B1K15: P1.37, U3.61 (DATA1)
/B1K16: P1.38, U3.62 (DATA0)
/B1L12: P1.49, U3.47 (DATA13)
/B1L13: P1.50, U3.48 (DATA12)
/B1L14: P1.40, U3.60 (DATA2)
/B1L16: P1.39, U3.59 (DATA3)
/B1M13: P1.47, U3.49 (DATA11)
/B1M14: P1.48, U3.50 (DATA10)
/B1M15: P1.43, U3.55 (DATA7)
/B1M16: P1.44, U3.56 (DATA6)
/B1N14: P1.45, U3.52 (DATA9)
/B1N16: P1.46, U3.54 (DATA8)
/B1P15: P1.51, U3.45 (DATA15)
/B1P16: P1.52, U3.46 (DATA14)
/B1R12: P1.60, U3.38 (DATA22)
/B1R14: P1.55, U3.41 (DATA19)
/B1R15: P1.53, U3.43 (DATA17)
/B1R16: P1.54, U3.44 (DATA16)
/B1T12: P1.59, U3.37 (DATA23)
/B1T13: P1.57, U3.39 (DATA21)
/B1T14: P1.58, U3.40 (DATA20)
/B1T15: P1.56, U3.42 (DATA18)
/B2L7: P2.48
/B2M6: P2.40
/B2M7: P2.45
/B2M9: P2.56
/B2M10: P2.57
/B2M11: P2.60
/B2N5: P2.42
/B2N6: P2.44
/B2N8: P2.47
/B2N9: P2.55
/B2P4: P2.41
/B2P5: P2.43
/B2P6: P2.46
/B2P9: P2.49
/B2P11: P2.58
/B2P12: P2.59
/B2R5: P2.52
/B2T4: P2.50
/B2T5: P2.51
/B2T6: P2.53
/B2T7: P2.54
/BSEL: R15.2, R21.1, R28.2, U4.15, W1.1
/CTL1: R26.1, U4.8
/CTL2: R24.1, U4.7
/CTL3: R27.1, U4.6
/DE_: P2.34, U4.2
/DKEN: R16.2, R22.1, U4.35
/DSEL: R14.2, R20.1, R25.2, U4.14, W2.1
/EDGE: R11.2, R17.1, U4.9
/EXTINT: P3.2, R7.2, U3.28 (INT)
/EXTPD: P3.1, R8.1, U3.22 (PD)
/EXTSCL: P3.3, R6.2, U3.35 (SCL)
/EXTSDA: P3.4, R5.2, U3.36 (SDA)
/HDMI1_SH: J1.SH, TP1.1
/HDMI2_SH: J2.SH, TP2.1
/HPD: J1.19 (HPD), R4.1, U3.16 (HPD)
/HSYNC_: P2.33, U4.4
/IDCK+: P2.25, U4.57
/IDCK-: P2.24, R9.1, U4.56
/ISEL: R13.2, R19.1, U4.13
/MSEN: R23.1, U4.11
/PD: R12.2, R18.1, U4.10
/SCL: J1.15 (SCL), R1.2, U3.33 (DDCSCL)
/SCL_: J2.15 (SCL), R28.1
/SDA: J1.16 (SDA), R2.2, U3.34 (DDCSDA)
/SDA_: J2.16 (SDA), R25.1
/TX0+: J1.7 (D0+), U3.21 (TX0+)
/TX0-: J1.9 (D0-), U3.20 (TX0-)
/TX1+: J1.4 (D1+), U3.24 (TX1+)
/TX1-: J1.6 (D1-), U3.23 (TX1-)
/TX2+: J1.1 (D2+), U3.27 (TX2+)
/TX2-: J1.3 (D2-), U3.26 (TX2-)
/TXC+: J1.10 (CLK+), U3.18 (TXC+)
/TXC-: J1.12 (CLK-), U3.17 (TXC-)
/VSYNC_: P2.36, U4.5
/_TX0+: J2.7 (D0+), U4.25
/_TX0-: J2.9 (D0-), U4.24
/_TX1+: J2.4 (D1+), U4.28
/_TX1-: J2.6 (D1-), U4.27
/_TX2+: J2.1 (D2+), U4.31
/_TX2-: J2.3 (D2-), U4.30
/_TXC+: J2.10 (CLK+), U4.22
/_TXC-: J2.12 (CLK-), U4.21
AVDD1V8: C12.1, C19.1, C20.1, C21.1, L3.2, U3.15 (AVDD), U3.19 (AVDD), U3.25 (AVDD)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.1, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, J1.2 (D2S), J1.5 (D1S), J1.8 (D0S), J1.11 (CLKS), J1.13 (CEC), J1.14 (RES), J1.17 (DDC/CEC/HEC), J2.2 (D2S), J2.5 (D1S), J2.8 (D0S), J2.11 (CLKS), J2.17 (DDC/CEC/HEC), P1.1, P1.2, P1.5, P1.6, P1.61, P1.62, P2.1, P2.2, P2.5, P2.6, P2.61, P2.62, P4.11, P4.12, R3.2, R4.2, R8.2, R9.2, R17.2, R18.2, R19.2, R20.2, R21.2, R22.2, U1.1 (GND), U2.1 (GND), U3.30 (CEC), U3.32 (CEC_CLK), U3.65 (PAD/GND), U4.16, U4.17, U4.20, U4.26, U4.32, U4.48, U4.64, U4.65
unnamed: C3.1, C4.1, L1.1, U1.2 (VO)
unnamed: C8.1, C9.1, C11.1, C13.2, L2.1, L3.1, L4.1, U2.2 (VO)
unnamed: R3.1, U3.14 (R_EXT)
unnamed: R10.1, U4.19
PVDD1V8: C14.1, C22.1, L4.2, U3.12 (PVDD), U3.13 (BGVDD)

Board: 2 copper layers, 84.1 x 67.1 mm, 75 parts (34 on the bottom side), 122 nets.

## Commit log

2019-06-11 pdf added
